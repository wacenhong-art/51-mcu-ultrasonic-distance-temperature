# Keil uVision project improved_p26.uvproj, settings and files
target improved_p26 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: improved_p26 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: IMPROVED=1,TEMP_P26=1
  group Application
    ./: main.c
